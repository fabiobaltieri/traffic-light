## firmware/boards/balto/traffic_light/board.yml
```yaml
board:
  name: traffic_light
  full_name: Traffic light
  vendor: balto
  socs:
  - name: esp32c3
```
